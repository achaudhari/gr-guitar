<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>wah_wah_envelope_ex</value></param>
<param><key>author</key><value>Ashish Chaudhari</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Wah-Wah Envelope Example</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>damp_factor</value></param>
<param><key>value</key><value>param_damp_factor</value></param>
<param><key>gui_hint</key><value>0,1,1,2</value></param>
<param><key>label</key><value>Damping</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.1</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>1.0</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>effect_en</value></param>
<param><key>value</key><value>param_enabled</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Effect Enabled</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>env_gain</value></param>
<param><key>value</key><value>param_env_gain</value></param>
<param><key>gui_hint</key><value>1,1,1,2</value></param>
<param><key>label</key><value>Envelope Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1.0</value></param>
<param><key>step</key><value>1.0</value></param>
<param><key>stop</key><value>10.0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>param_gain</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label</key><value>Signal Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.1</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>1.0</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>max_cutoff_freq</value></param>
<param><key>value</key><value>param_max_cutoff_freq</value></param>
<param><key>gui_hint</key><value>1,3,1,3</value></param>
<param><key>label</key><value>Max Cutoff Freq</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>20.0</value></param>
<param><key>step</key><value>250</value></param>
<param><key>stop</key><value>samp_rate/8</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>min_cutoff_freq</value></param>
<param><key>value</key><value>param_min_cutoff_freq</value></param>
<param><key>gui_hint</key><value>0,3,1,3</value></param>
<param><key>label</key><value>Min Cutoff Freq</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>20.0</value></param>
<param><key>step</key><value>250</value></param>
<param><key>stop</key><value>samp_rate/8</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink</value></param>
<param><key>samp_rate</key><value>44100</value></param>
</block>
<block>
<key>blocks_abs_xx</key>
<param><key>id</key><value>blocks_abs_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>env_gain</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0</value></param>
<param><key>const</key><value>gain</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>cwd_changer</value></param>
<param><key>source_code</key><value># this module will be imported in the into your flowgraph
import os
script_path = os.path.dirname(os.path.realpath(__file__))
os.chdir(script_path)</value></param>
</block>
<block>
<key>guitar_wah_filter</key>
<param><key>id</key><value>guitar_wah_filter_0</value></param>
<param><key>damp</key><value>damp_factor</value></param>
<param><key>enabled</key><value>effect_en</value></param>
<param><key>envelope_src</key><value>S</value></param>
<param><key>lfo_freq</key><value>0.0</value></param>
<param><key>cutoff_freq_max</key><value>max_cutoff_freq</value></param>
<param><key>cutoff_freq_min</key><value>min_cutoff_freq</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>param_damp_factor</value></param>
<param><key>label</key><value>Damping Factor</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.7</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>param_enabled</value></param>
<param><key>label</key><value>Enabled</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>param_env_gain</value></param>
<param><key>label</key><value>Envelope Gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>5.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>param_gain</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>param_max_cutoff_freq</value></param>
<param><key>label</key><value>Max Cutoff Freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>3000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>param_min_cutoff_freq</value></param>
<param><key>label</key><value>Min Cutoff Freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>300</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>plot_tab</value></param>
<param><key>gui_hint</key><value>2,0,16,6</value></param>
<param><key>label0</key><value>Time Domain Plots</value></param>
<param><key>label1</key><value>Waterfall Plots</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_0</value></param>
<param><key>gui_hint</key><value>plot_tab@0: 0,0,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"green"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>Original Signal</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>int(samp_rate/1)</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.05</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_1</value></param>
<param><key>gui_hint</key><value>plot_tab@0: 1,0,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>Wah'ed Signal</value></param>
<param><key>size</key><value>int(samp_rate/1)</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.05</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_0</value></param>
<param><key>bw</key><value>samp_rate/2</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>plot_tab@1: 0,0,1,1</value></param>
<param><key>int_max</key><value>0</value></param>
<param><key>int_min</key><value>-120</value></param>
<param><key>color1</key><value>3</value></param>
<param><key>name</key><value>Original Signal</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.05</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_1</value></param>
<param><key>bw</key><value>samp_rate/2</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>plot_tab@1: 0,1,1,1</value></param>
<param><key>int_max</key><value>0</value></param>
<param><key>int_min</key><value>-120</value></param>
<param><key>color1</key><value>3</value></param>
<param><key>name</key><value>Wah'ed Signal</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.05</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>44100</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0</value></param>
<param><key>alpha</key><value>0.0003</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>wavfile_source</value></param>
<param><key>file</key><value>samples/sample_3.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<connection><source_block_id>blocks_abs_xx_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>guitar_wah_filter_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>qtgui_time_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>blocks_abs_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>guitar_wah_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>qtgui_waterfall_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>guitar_wah_filter_0</source_block_id><sink_block_id>audio_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>guitar_wah_filter_0</source_block_id><sink_block_id>qtgui_time_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>guitar_wah_filter_0</source_block_id><sink_block_id>qtgui_waterfall_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wavfile_source</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
