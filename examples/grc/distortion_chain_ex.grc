<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>distortion_chain_ex</value></param>
<param><key>author</key><value>Ashish Chaudhari</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Distortion Chain Example</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>boost</value></param>
<param><key>value</key><value>param_boost</value></param>
<param><key>gui_hint</key><value>0,3,1,3</value></param>
<param><key>label</key><value>Boost</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1.0</value></param>
<param><key>step</key><value>1.0</value></param>
<param><key>stop</key><value>20.0</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>dist_func</value></param>
<param><key>value</key><value>L</value></param>
<param><key>gui_hint</key><value>0,1,1,2</value></param>
<param><key>label0</key><value>Linear</value></param>
<param><key>label1</key><value>Quadratic</value></param>
<param><key>label2</key><value>Exponential</value></param>
<param><key>label3</key><value>Inverse</value></param>
<param><key>label4</key><value>Sine</value></param>
<param><key>label</key><value>Distortion Function</value></param>
<param><key>num_opts</key><value>5</value></param>
<param><key>option0</key><value>L</value></param>
<param><key>option1</key><value>Q</value></param>
<param><key>option2</key><value>E</value></param>
<param><key>option3</key><value>I</value></param>
<param><key>option4</key><value>S</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>effect_en</value></param>
<param><key>value</key><value>param_enabled</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Effect Enabled</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fb_taps_x5</value></param>
<param><key>value</key><value>[1.0, -8.291059288298642, 31.968540091201724, -75.28500148906959, 119.70907498509254, -134.14207078838928, 107.20829278509079, -60.32561513611677, 22.87426975190269, -5.280233075370271, 0.5639952704728106]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ff_taps_x5</value></param>
<param><key>value</key><value>[0.00040246997599371843, -0.0018158326112469709, 0.004462495499446449, -0.007321598828586269, 0.009335211042713355, -0.009953383793105623, 0.009335211042713362, -0.007321598828586287, 0.004462495499446459, -0.001815832611246976, 0.0004024699759937197]</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>filt_cutoff</value></param>
<param><key>value</key><value>param_cutoff_freq</value></param>
<param><key>gui_hint</key><value>1,3,1,3</value></param>
<param><key>label</key><value>Post-Shelf Cutoff Freq</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>20.0</value></param>
<param><key>step</key><value>samp_rate/100</value></param>
<param><key>stop</key><value>samp_rate/4</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>wet_mix</value></param>
<param><key>value</key><value>param_wet_dry_mix</value></param>
<param><key>gui_hint</key><value>1,0,1,3</value></param>
<param><key>label</key><value>Wet/Dry Mix</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>1.0</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink</value></param>
<param><key>samp_rate</key><value>44100</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>5.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>cwd_changer</value></param>
<param><key>source_code</key><value># this module will be imported in the into your flowgraph
import os
script_path = os.path.dirname(os.path.realpath(__file__))
os.chdir(script_path)</value></param>
</block>
<block>
<key>guitar_distortion</key>
<param><key>id</key><value>guitar_distortion</value></param>
<param><key>boost</key><value>boost</value></param>
<param><key>dist_func</key><value>dist_func</value></param>
<param><key>enabled</key><value>effect_en</value></param>
<param><key>wet_gamma</key><value>wet_mix</value></param>
</block>
<block>
<key>guitar_iir_decimator</key>
<param><key>id</key><value>guitar_iir_decimator</value></param>
<param><key>decimation</key><value>5</value></param>
<param><key>fftaps</key><value>ff_taps_x5</value></param>
<param><key>fbtaps</key><value>fb_taps_x5</value></param>
</block>
<block>
<key>guitar_iir_interpolator</key>
<param><key>id</key><value>guitar_iir_interpolator</value></param>
<param><key>fftaps</key><value>ff_taps_x5</value></param>
<param><key>fbtaps</key><value>fb_taps_x5</value></param>
<param><key>interpolation</key><value>5</value></param>
</block>
<block>
<key>guitar_shelving_filter</key>
<param><key>id</key><value>guitar_shelving_filter</value></param>
<param><key>cutoff_freq</key><value>filt_cutoff</value></param>
<param><key>type</key><value>high-shelf</value></param>
<param><key>gain</key><value>-15 if effect_en else 0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>param_boost</value></param>
<param><key>label</key><value>Boost</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>3.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>param_cutoff_freq</value></param>
<param><key>label</key><value>Post-Shelf Cutoff Freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>4000.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>param_dist_func</value></param>
<param><key>label</key><value>Distortion Function</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>Linear</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>param_enabled</value></param>
<param><key>label</key><value>Enabled</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>param_wet_dry_mix</value></param>
<param><key>label</key><value>Wet/Dry Mix</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>plot_tab</value></param>
<param><key>gui_hint</key><value>2,0,16,6</value></param>
<param><key>label0</key><value>Time Domain Plots</value></param>
<param><key>label1</key><value>Waterfall Plots</value></param>
<param><key>label2</key><value>Spectrum Plots</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>plot_tab@2: 0,0,1,1</value></param>
<param><key>name</key><value>"Original Signal"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.05</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-120</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>plot_tab@2: 1,0,1,1</value></param>
<param><key>name</key><value>"Distorted Signal"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.05</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-120</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_0</value></param>
<param><key>gui_hint</key><value>plot_tab@0: 0,0,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>Original Signal</value></param>
<param><key>size</key><value>int(samp_rate/2)</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.05</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_1</value></param>
<param><key>gui_hint</key><value>plot_tab@0: 1,0,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>Distorted Signal</value></param>
<param><key>size</key><value>int(samp_rate/2)</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.05</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>plot_tab@1: 0,0,1,1</value></param>
<param><key>int_max</key><value>0</value></param>
<param><key>int_min</key><value>-120</value></param>
<param><key>color1</key><value>3</value></param>
<param><key>name</key><value>Original Signal</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.05</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_1</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>plot_tab@1: 0,1,1,1</value></param>
<param><key>int_max</key><value>0</value></param>
<param><key>int_min</key><value>-120</value></param>
<param><key>color1</key><value>3</value></param>
<param><key>name</key><value>Distorted Signal</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.05</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>44100</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>wavfile_source</value></param>
<param><key>file</key><value>samples/sample_1.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>guitar_distortion</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>guitar_distortion</source_block_id><sink_block_id>guitar_iir_decimator</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>guitar_iir_decimator</source_block_id><sink_block_id>guitar_shelving_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>guitar_iir_interpolator</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>guitar_shelving_filter</source_block_id><sink_block_id>audio_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>guitar_shelving_filter</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>guitar_shelving_filter</source_block_id><sink_block_id>qtgui_time_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>guitar_shelving_filter</source_block_id><sink_block_id>qtgui_waterfall_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wavfile_source</source_block_id><sink_block_id>guitar_iir_interpolator</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wavfile_source</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wavfile_source</source_block_id><sink_block_id>qtgui_time_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wavfile_source</source_block_id><sink_block_id>qtgui_waterfall_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
